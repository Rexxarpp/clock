# Keil uVision project clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: clock +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c hc595.c delay.c display.c key.c spi.c ds1302.c
  group head Group
    ./: delay.h hc595.h display.h key.h ds1302.h spi.h
